options:
  parameters:
    author: ee24m312
    generate_options: qt_gui
    id: rx_side
    output_language: python
    title: ucb_bsed_project
  states: {}

blocks:
- name: current_interference_display
  id: variable_qtgui_label
  parameters:
    comment: |-
      Show current interference 
      frequencies
    gui_hint: 6,0,1,4
    label: 'Current Interference On:'
    type: string
    value: Initializing...
  states: {}
- name: exploration_param
  id: variable_qtgui_range
  parameters:
    comment: |-
      UCB exploration parameter - 
      REDUCED for faster switching
    gui_hint: 3,0,1,2
    label: UCB Exploration (c)
    start: '0.1'
    step: '0.1'
    stop: '3.0'
    value: '1'
  states: {}
- name: hop_interval
  id: variable_qtgui_range
  parameters:
    comment: |-
      Sample collection period
      (for info only - UCB decides when to switch)
    gui_hint: 2,0,1,2
    label: Sample Collection Info (s)
    start: '0.1'
    step: '0.1'
    stop: '3.0'
    value: '0.8'
  states: {}
- name: interference_interval
  id: variable_qtgui_range
  parameters:
    comment: |-
      How often interference
       pattern changes (seconds)
    gui_hint: 5,0,1,2
    label: Interference Change Interval (s)
    rangeType: int
    start: '0'
    step: '10'
    stop: '300'
    value: '5'
  states: {}
- name: interference_strength
  id: variable_qtgui_range
  parameters:
    comment: |-
      Base interference strength - 
      applied to random frequencies
    gui_hint: 1,0,1,2
    label: Interference Strength
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.001'
  states: {}
- name: min_samples
  id: variable_qtgui_range
  parameters:
    comment: |-
      Minimum samples per frequency - 
      REDUCED for faster switching
    gui_hint: 4,0,1,2
    label: Min Samples per Freq
    rangeType: int
    start: '5000'
    step: '1000'
    stop: '2500000'
    value: '20000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: RX gain
    gui_hint: 0,2,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sync
  id: variable
  parameters:
    comment: USRP synchronization parameter
    value: '"unknown"'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 6e3
    quad_rate: 48000*4
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class external_reward_block(gr.sync_block):
          """
          Reward calculator using ONLY external interference on USRP signal.
          - Input: complex baseband from USRP
          - Output: PMT double reward in [0,1]
          """

          def __init__(self, update_rate=200, window_size=1024):
              gr.sync_block.__init__(
                  self,
                  name="external_reward_block",
                  in_sig=[np.complex64],
                  out_sig=None,
              )

              self.update_rate  = update_rate      # how often to send reward (in samples)
              self.window_size  = window_size      # samples used for statistics
              self.sample_count = 0

              # small circular buffer
              self.buf = np.zeros(self.window_size, dtype=np.complex64)
              self.buf_pos = 0
              self.buf_filled = False

              # output port
              self.reward_port = pmt.intern("reward_out")
              self.message_port_register_out(self.reward_port)

              print("✅ EXTERNAL reward block started (no internal interference).")

          def _compute_reward(self, x):
              """
              x: complex samples (numpy array)
              Idea:
                - signal_power = mean(|x|^2)
                - variance = var(|x|)
                - high variance / power  => more interference  => low reward
              """
              try:
                  if len(x) < 32:
                      return 0.0

                  mag = np.abs(x)
                  power = np.mean(mag**2)

                  if power <= 1e-12:
                      return 0.0

                  var_mag = np.var(mag)
                  inter_metric = var_mag / power   # higher => more bursty / interfered

                  # map interference metric to reward [0,1]
                  # low inter_metric -> reward ~1
                  # high inter_metric -> reward ~0
                  reward = 1.0 / (1.0 + inter_metric)

                  # clamp
                  reward = float(max(0.0, min(1.0, reward)))
                  return reward

              except Exception as e:
                  print("❌ Reward error:", e)
                  return 0.0

          def work(self, input_items, output_items):
              samples = input_items[0]

              if len(samples) == 0:
                  return 0

              # circular buffer update
              n = len(samples)
              if n >= self.window_size:
                  self.buf[:] = samples[-self.window_size:]
                  self.buf_pos = 0
                  self.buf_filled = True
              else:
                  end = self.buf_pos + n
                  if end <= self.window_size:
                      self.buf[self.buf_pos:end] = samples
                  else:
                      first = self.window_size - self.buf_pos
                      self.buf[self.buf_pos:] = samples[:first]
                      self.buf[:(n - first)] = samples[first:]
                  self.buf_pos = (self.buf_pos + n) % self.window_size
                  if self.buf_pos == 0:
                      self.buf_filled = True

              self.sample_count += n

              # send reward periodically
              if self.sample_count >= self.update_rate and self.buf_filled:
                  self.sample_count = 0

                  # use recent window
                  recent = np.copy(self.buf)

                  reward = self._compute_reward(recent)
                  msg = pmt.from_double(reward)
                  self.message_port_pub(self.reward_port, msg)

              return n
    update_rate: '200'
    window_size: '1024'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      import time
      from gnuradio import gr


      class adaptive_ucb_hopper(gr.sync_block):

          def __init__(self, c=1, min_samples_per_freq=2000, good_reward_threshold=0.7, max_stay_cycles=5):
              gr.sync_block.__init__(
                  self,
                  name="adaptive_ucb_hopper",
                  in_sig=[np.complex64],
                  out_sig=None
              )

              self.frequencies = [2.412e9, 2.437e9, 2.462e9, 2.472e9, 2.480e9]
              self.freq_names = ["2.412GHz", "2.437GHz", "2.462GHz", "2.472GHz", "2.480GHz"]
              self.K = len(self.frequencies)

              self.c = c
              self.min_samples_per_freq = min_samples_per_freq

              self.n_selections = [0] * self.K
              self.sum_rewards = [0.0] * self.K
              self.recent_rewards = [[] for _ in range(self.K)]
              self.window_size = 30
              self.total_rounds = 0
              self.current_arm = 0

              self.cycles_on_good_channel = 0
              self.good_reward_threshold = good_reward_threshold
              self.max_stay_cycles = max_stay_cycles

              self.phase = "init"
              self.init_completed = [False] * self.K

              self.samples_on_current_freq = 0
              self.last_reward_time = time.time()

              self.message_port_register_out(pmt.intern("tx_freq"))
              self.message_port_register_out(pmt.intern("rx_freq"))
              self.message_port_register_out(pmt.intern("interference_freq"))
              self.message_port_register_in(pmt.intern("reward_in"))
              self.set_msg_handler(pmt.intern("reward_in"), self.handle_reward)

              self.switch_to_frequency(0)
              print("✅ STICKY UCB Hopper Started (Smart Interference Detection)")

          # --------------------------------------------------

          def switch_to_frequency(self, arm):
              self.current_arm = arm
              self.samples_on_current_freq = 0
              self.cycles_on_good_channel = 0
              freq = self.frequencies[arm]

              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(freq))
              self.message_port_pub(pmt.intern("tx_freq"), msg)
              self.message_port_pub(pmt.intern("rx_freq"), msg)
              self.message_port_pub(pmt.intern("interference_freq"), msg)

              print(f"🔄 SWITCH → {self.freq_names[arm]} ({freq/1e9:.3f} GHz)")

          # --------------------------------------------------

          def calculate_ucb_values(self):
              ucb_vals = []
              for i in range(self.K):
                  if self.n_selections[i] == 0:
                      ucb = float("inf")
                  else:
                      if len(self.recent_rewards[i]) > 0:
                          avg = np.mean(self.recent_rewards[i])
                      else:
                          avg = self.sum_rewards[i] / self.n_selections[i]

                      conf = self.c * np.sqrt(np.log(self.total_rounds + 1) / self.n_selections[i])
                      ucb = avg + conf

                  ucb_vals.append(ucb)

              return ucb_vals

          # --------------------------------------------------

          def select_next_arm_ucb(self):
              ucb_vals = self.calculate_ucb_values()
              return int(np.argmax(ucb_vals))

          # --------------------------------------------------

          def handle_reward(self, msg):
              try:
                  reward = pmt.to_double(msg)
                  arm = self.current_arm

                  self.sum_rewards[arm] += reward
                  self.n_selections[arm] += 1
                  self.total_rounds += 1

                  self.recent_rewards[arm].append(reward)
                  if len(self.recent_rewards[arm]) > self.window_size:
                      self.recent_rewards[arm].pop(0)

                  if self.phase == "init":
                      if self.samples_on_current_freq >= self.min_samples_per_freq:
                          self.init_completed[arm] = True

                          next_arm = None
                          for i in range(self.K):
                              if not self.init_completed[i]:
                                  next_arm = i
                                  break

                          if next_arm is not None:
                              self.switch_to_frequency(next_arm)
                          else:
                              self.phase = "adaptive"
                              print("\n" + "="*60)
                              print("✅ INITIALIZATION COMPLETE → SMART ADAPTIVE MODE")
                              print("="*60 + "\n")

                              best_arm = self.select_next_arm_ucb()
                              if best_arm != self.current_arm:
                                  self.switch_to_frequency(best_arm)
                              else:
                                  self.samples_on_current_freq = 0

                  else:
                      if self.samples_on_current_freq >= self.min_samples_per_freq:
                          current_avg = np.mean(self.recent_rewards[arm]) if len(self.recent_rewards[arm]) > 0 else 0

                          has_interference = current_avg < self.good_reward_threshold
                          time_to_explore = self.cycles_on_good_channel >= self.max_stay_cycles

                          if has_interference or time_to_explore:
                              if has_interference:
                                  print(f"\n⚠️ INTERFERENCE DETECTED on {self.freq_names[arm]} (Reward {current_avg:.2f})")
                              else:
                                  print(f"\n🔍 EXPLORATION PHASE")

                              next_arm = self.select_next_arm_ucb()

                              if next_arm != self.current_arm:
                                  self.switch_to_frequency(next_arm)
                              else:
                                  self.samples_on_current_freq = 0
                                  self.cycles_on_good_channel = 0
                          else:
                              self.samples_on_current_freq = 0
                              self.cycles_on_good_channel += 1

                              if self.cycles_on_good_channel % 5 == 0:
                                  print(f"🌟 STAYING on {self.freq_names[arm]} | Reward: {current_avg:.2f}")

              except Exception as e:
                  print("❌ Reward handling error:", e)

          # --------------------------------------------------

          def work(self, input_items, output_items):
              n = len(input_items[0])
              self.samples_on_current_freq += n
              return n
    c: exploration_param
    good_reward_threshold: '0.7'
    max_stay_cycles: '25'
    min_samples_per_freq: min_samples
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='freq_to_udp_pdu', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  if pmt.is_pair(msg):
                      freq = pmt.to_double(pmt.cdr(msg))
                      s = str(freq).encode('utf-8')
                      vec = pmt.init_u8vector(len(s), list(s))
                      pdu = pmt.cons(pmt.make_dict(), vec)
                      self.message_port_pub(pmt.intern('out'), pdu)
                      print("UDP Sent freq =", freq)
              except Exception as e:
                  print("TX block error:", e)
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import csv
      import os


      class smart_logger(gr.sync_block):

          def __init__(self, log_interval=0.2):
              gr.sync_block.__init__(
                  self,
                  name="smart_logger",
                  in_sig=[np.complex64],
                  out_sig=None
              )

              os.makedirs("logs", exist_ok=True)
              self.t0 = time.time()

              self.log = open("logs/final_log3.csv", "w", newline="")
              self.writer = csv.writer(self.log)
              self.writer.writerow([
                  "time_sec",
                  "frequency_hz",
                  "snr_db",
                  "ber",
                  "rx_power",
                  "reward"
              ])

              self.freq = 0.0
              self.reward = 0.0
              self.rx_power = 0.0
              self.snr = 0.0
              self.ber = 0.0

              self.buffer = []

              self.log_interval = log_interval
              self.last_log_time = 0

              # message ports
              self.message_port_register_in(pmt.intern("freq_in"))
              self.set_msg_handler(pmt.intern("freq_in"), self.handle_freq)

              self.message_port_register_in(pmt.intern("reward_in"))
              self.set_msg_handler(pmt.intern("reward_in"), self.handle_reward)

              print("✅ Smart Logger with SNR + BER started")

          # -------------------------

          def handle_freq(self, msg):
              try:
                  if pmt.is_pair(msg):
                      self.freq = pmt.to_double(pmt.cdr(msg))
              except:
                  pass

          def handle_reward(self, msg):
              try:
                  self.reward = pmt.to_double(msg)
              except:
                  pass

          # -------------------------

          def calculate_snr(self, samples):
              if len(samples) < 64:
                  return -50

              signal_power = np.mean(np.abs(samples) ** 2)

              fft = np.fft.fft(samples[:256])
              ps = np.abs(fft) ** 2
              noise_floor = np.mean(np.sort(ps)[:int(0.1 * len(ps))])

              if noise_floor <= 0:
                  return -50

              return 10 * np.log10(signal_power / noise_floor)

          def estimate_ber(self, snr_db):
              # lightweight approximation (no scipy)
              snr_linear = 10 ** (snr_db / 10)

              if snr_db < 0:
                  return 0.5
              elif snr_db > 20:
                  return 1e-6
              else:
                  return 0.5 * np.exp(-snr_linear)

          # -------------------------

          def work(self, input_items, output_items):
              x = input_items[0]

              if len(x) > 0:
                  self.buffer.extend(x)
                  self.rx_power = float(np.mean(np.abs(x) ** 2))

              # keep buffer small
              if len(self.buffer) > 1000:
                  self.buffer = self.buffer[-500:]

              current_time = time.time()

              if current_time - self.last_log_time >= self.log_interval:
                  self.last_log_time = current_time

                  if len(self.buffer) >= 256:
                      samples = np.array(self.buffer[-256:])
                      self.snr = self.calculate_snr(samples)
                      self.ber = self.estimate_ber(self.snr)

                  t = current_time - self.t0

                  self.writer.writerow([
                      t,
                      self.freq,
                      self.snr,
                      self.ber,
                      self.rx_power,
                      self.reward
                  ])

                  if int(t) % 2 == 0:
                      self.log.flush()

              return len(x)

          # -------------------------

          def stop(self):
              try:
                  self.log.close()
              except:
                  pass
              return super().stop()
    log_interval: '0.2'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class simple_ucb_hopper(gr.sync_block):
          """
          PURE UCB frequency hopper.
          - Input: complex samples from USRP (sirf count ke liye)
          - Message in: reward_in (PMT double, [0,1])
          - Message out: tx_freq, rx_freq (pair { "freq" , double })
          """

          def __init__(self,
                       c=1.0,
                       min_samples_per_freq=20000):
              gr.sync_block.__init__(
                  self,
                  name="simple_ucb_hopper",
                  in_sig=[np.complex64],
                  out_sig=None,
              )

              # Arms (frequencies)
              self.frequencies = [
                  2.412e9,
                  2.437e9,
                  2.462e9,
                  2.472e9,
                  2.480e9,
              ]
              self.freq_names = [
                  "2.412 GHz",
                  "2.437 GHz",
                  "2.462 GHz",
                  "2.472 GHz",
                  "2.480 GHz",
              ]
              self.K = len(self.frequencies)

              # UCB parameters
              self.c = float(c)
              self.min_samples_per_freq = int(min_samples_per_freq)

              # Stats
              self.n_selections = [0] * self.K
              self.sum_rewards  = [0.0] * self.K
              self.total_rounds = 0

              # Current state
              self.current_arm = 0
              self.samples_on_current_freq = 0

              # Message ports
              self.message_port_register_out(pmt.intern("tx_freq"))
              self.message_port_register_out(pmt.intern("rx_freq"))
              self.message_port_register_in(pmt.intern("reward_in"))
              self.set_msg_handler(pmt.intern("reward_in"), self.handle_reward)

              # Start on arm 0
              self._switch_to_arm(0)
              print("✅ SIMPLE UCB Hopper started.")

          # -----------------------------

          def _switch_to_arm(self, arm):
              self.current_arm = int(arm)
              self.samples_on_current_freq = 0

              freq = float(self.frequencies[self.current_arm])
              msg  = pmt.cons(pmt.intern("freq"), pmt.from_double(freq))

              self.message_port_pub(pmt.intern("tx_freq"), msg)
              self.message_port_pub(pmt.intern("rx_freq"), msg)

              print(f"🔁 SWITCH → {self.freq_names[self.current_arm]} ({freq/1e9:.3f} GHz)")

          # -----------------------------

          def _ucb_values(self):
              ucb = []
              for i in range(self.K):
                  if self.n_selections[i] == 0:
                      ucb.append(float("inf"))
                  else:
                      avg = self.sum_rewards[i] / self.n_selections[i]
                      conf = self.c * np.sqrt(
                          np.log(self.total_rounds + 1.0) / self.n_selections[i]
                      )
                      ucb.append(avg + conf)
              return ucb

          # -----------------------------

          def _select_next_arm(self):
              vals = self._ucb_values()
              return int(np.argmax(vals))

          # -----------------------------

          def handle_reward(self, msg):
              try:
                  reward = float(pmt.to_double(msg))
                  arm    = self.current_arm

                  # update stats
                  self.sum_rewards[arm] += reward
                  self.n_selections[arm] += 1
                  self.total_rounds += 1

                  # only decide if enough samples seen on this arm
                  if self.samples_on_current_freq >= self.min_samples_per_freq:
                      next_arm = self._select_next_arm()
                      self._switch_to_arm(next_arm)

              except Exception as e:
                  print("❌ UCB reward error:", e)

          # -----------------------------

          def work(self, input_items, output_items):
              n = len(input_items[0])
              self.samples_on_current_freq += n
              return n
    c: '1'
    min_samples_per_freq: '20000'
  states: {state: disabled}
- name: epy_block_dynamic_interference_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import random
      import pmt
      import threading
      import time


      class dynamic_interference_simulator(gr.sync_block):
          """
          Dynamic interference simulator for 2.4, 2.5, 5.0, 4.9, 5.5 GHz
          """

          def __init__(self, interference_strength=0.001, change_interval=5):
              gr.sync_block.__init__(
                  self,
                  name="dynamic_interference_simulator",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.freq_list = [2.412e9, 2.437e9, 2.462e9, 2.472e9, 2.480e9]
              self.freq_names = ["2.412GHz", "2.437GHz", "2.462GHz", "2.472GHz", "2.480GHz"]

              self.interference_strength = interference_strength
              self.change_interval = change_interval
              self.current_freq = 2.412e9

              self.interference_frequencies = []
              self.last_change_time = 0

              self.lock = threading.Lock()

              self.freq_port = pmt.intern("freq_in")
              self.message_port_register_in(self.freq_port)
              self.set_msg_handler(self.freq_port, self.handle_freq_update)

              self.generate_new_interference_pattern()

              print(f"[INTERFERENCE] Initialized - Changes every {change_interval} seconds")

          # --------------------------------------------------

          def generate_new_interference_pattern(self):
              with self.lock:
                  num_interference_freqs = random.randint(1, 2)
                  self.interference_frequencies = random.sample(
                      self.freq_list, num_interference_freqs
                  )

                  names = []
                  for f in self.interference_frequencies:
                      names.append(self.freq_names[self.freq_list.index(f)])

                  print(f"\n🚨 [INTERFERENCE CHANGE]")
                  print(f"    Affected frequencies: {', '.join(names)}")
                  print(f"    Strength: {self.interference_strength:.3f}")
                  print(f"    Next change in: {self.change_interval} seconds\n")

                  self.last_change_time = time.time()

          # --------------------------------------------------

          def handle_freq_update(self, msg):
              try:
                  if pmt.is_pair(msg):
                      freq = pmt.to_double(pmt.cdr(msg))
                      with self.lock:
                          self.current_freq = freq
              except Exception as e:
                  print(f"[INTERFERENCE ERROR] {e}")

          # --------------------------------------------------

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]

              y[:] = x

              current_time = time.time()
              if current_time - self.last_change_time >= self.change_interval:
                  self.generate_new_interference_pattern()

              with self.lock:
                  strength = self.interference_strength
                  current_freq = self.current_freq
                  interference_freqs = self.interference_frequencies.copy()

              for f in interference_freqs:
                  if abs(current_freq - f) < 0.01e9:
                      noise_power = strength * 1
                      noise = (np.random.randn(len(x)) + 1j*np.random.randn(len(x))) * np.sqrt(noise_power)
                      y[:] += noise
                      break

              return len(y)
    change_interval: interference_interval
    comment: |-
      DYNAMIC interference for
      2.4-4.5 GHz frequency range
    interference_strength: interference_strength
  states: {}
- name: epy_block_enhanced_reward_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      import time
      from gnuradio import gr


      class enhanced_reward_calculator(gr.sync_block):
          """
          Enhanced reward calculation optimized for FAST UCB frequency hopping
          """

          def __init__(self, window_size=200, update_rate=20):
              gr.sync_block.__init__(
                  self,
                  name="enhanced_reward_calculator",
                  in_sig=[np.complex64],
                  out_sig=None,
              )

              self.window_size = window_size
              self.update_rate = update_rate
              self.sample_count = 0

              self.power_buffer = []
              self.signal_buffer = []

              self.sample_rate = 1e6

              self.reward_port = pmt.intern("reward_out")
              self.message_port_register_out(self.reward_port)

              print("[REWARD] Initialized for FAST switching - reduced latency")

          # -------------------------------

          def calculate_snr(self, samples):
              try:
                  if len(samples) < 32:
                      return -50

                  signal_power = np.mean(np.abs(samples) ** 2)

                  fft_size = min(256, len(samples))
                  fft_data = np.fft.fft(samples[:fft_size])
                  power_spectrum = np.abs(fft_data) ** 2
                  sorted_power = np.sort(power_spectrum)
                  noise_floor = np.mean(sorted_power[:int(0.1 * len(sorted_power))])

                  if signal_power <= 0 or noise_floor <= 0:
                      return -50

                  snr_db = 10 * np.log10(signal_power / noise_floor)
                  return max(snr_db, -50)

              except Exception:
                  return -50

          # -------------------------------

          def calculate_interference_metric(self, samples):
              try:
                  if len(samples) < 32:
                      return 0.5

                  signal_var = np.var(np.abs(samples))
                  var_penalty = min(signal_var * 100, 0.4)

                  fft_size = min(128, len(samples))
                  fft = np.fft.fft(samples[:fft_size])
                  power_spectrum = np.abs(fft) ** 2

                  mean_power = np.mean(power_spectrum)
                  std_power = np.std(power_spectrum)

                  if std_power > 0 and mean_power > 0:
                      outliers = np.sum(power_spectrum > (mean_power + 2 * std_power))
                      spectral_penalty = min((outliers / len(power_spectrum)) * 3, 0.4)
                  else:
                      spectral_penalty = 0.1

                  if len(self.power_buffer) >= 10:
                      recent_powers = np.array(self.power_buffer[-10:])
                      stability_var = np.var(recent_powers)
                      stability_penalty = min(stability_var * 20, 0.2)
                  else:
                      stability_penalty = 0.1

                  return min(var_penalty + spectral_penalty + stability_penalty, 1.0)

              except Exception:
                  return 0.5

          # -------------------------------

          def calculate_composite_reward(self, samples, power_samples):
              try:
                  snr_db = self.calculate_snr(samples)
                  interference = self.calculate_interference_metric(samples)

                  if len(power_samples) >= 5:
                      power_array = np.array(power_samples[-5:])
                      power_std = np.std(power_array)
                      power_mean = np.mean(power_array)
                      stability = 1.0 / (1.0 + power_std / power_mean) if power_mean > 0 else 0.0
                  else:
                      stability = 0.5

                  snr_normalized = (snr_db + 50) / 100
                  snr_normalized = max(0, min(1, snr_normalized))

                  reward = (
                      0.2 * snr_normalized +
                      0.1 * stability +
                      0.7 * (1 - interference)
                  )

                  if interference > 0.8:
                      reward *= 0.3
                  elif interference > 0.6:
                      reward *= 0.6

                  if self.sample_count % (self.update_rate * 20) == 0:
                      print(f"[FAST REWARD] SNR={snr_db:.1f}dB, "
                            f"Interf={interference:.2f}, "
                            f"Stab={stability:.2f} → {reward:.3f}")

                  return max(0.0, min(1.0, reward))

              except Exception:
                  return 0.0

          # -------------------------------

          def work(self, input_items, output_items):
              samples = input_items[0]
              if len(samples) == 0:
                  return 0

              self.signal_buffer.extend(samples)
              power_samples = np.abs(samples) ** 2
              self.power_buffer.extend(power_samples)

              if len(self.signal_buffer) > self.window_size:
                  self.signal_buffer = self.signal_buffer[-self.window_size // 2:]
              if len(self.power_buffer) > self.window_size:
                  self.power_buffer = self.power_buffer[-self.window_size // 2:]

              self.sample_count += len(samples)

              if self.sample_count % self.update_rate == 0:
                  if len(self.signal_buffer) >= 50:
                      reward = self.calculate_composite_reward(
                          np.array(self.signal_buffer[-75:]),
                          np.array(self.power_buffer[-75:])
                      )

                      reward_msg = pmt.from_double(float(reward))
                      self.message_port_pub(self.reward_port, reward_msg)

              return len(samples)
    comment: |-
      FAST reward calculator
      for aggressive UCB switching
    update_rate: '20'
    window_size: '2000'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 10.23.14.59
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: qtgui_freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"red"'
    comment: RX spectrum display
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,2,2,2
    label1: RX Signal
    name: '"RX Spectrum"'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '24'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 500e3
    center_freq0: '0'
    comment: RX USRP
    dev_addr: ''
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_freq
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: inter_freq
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '0']
- [epy_block_0, reward_out, epy_block_2, reward_in]
- [epy_block_0_1, rx_freq, epy_block_1_0, freq_in]
- [epy_block_0_1, rx_freq, virtual_sink_1, '0']
- [epy_block_0_1, tx_freq, epy_block_1, in]
- [epy_block_1, out, network_socket_pdu_0, pdus]
- [epy_block_dynamic_interference_0, '0', epy_block_enhanced_reward_0, '0']
- [epy_block_enhanced_reward_0, reward_out, epy_block_0_1, reward_in]
- [epy_block_enhanced_reward_0, reward_out, epy_block_1_0, reward_in]
- [rational_resampler_xxx_1, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1, '0']
- [uhd_usrp_source_0, '0', epy_block_1_0, '0']
- [uhd_usrp_source_0, '0', epy_block_dynamic_interference_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_rx, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_1, '0']
- [virtual_source_0, '0', qtgui_freq_sink_rx, freq]
- [virtual_source_0, '0', uhd_usrp_source_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
