options:
  parameters:
    author: ee24m312
    generate_options: qt_gui
    id: tx_side
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: RX gain
    gui_hint: 0,1,1,1
    label: tx_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sync
  id: variable
  parameters:
    comment: USRP synchronization parameter
    value: '"unknown"'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 6e3
    quad_rate: 48000*4
    tau: '75e-6'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: complex
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/iit-tp/Downloads/speech (1).wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='udp_pdu_to_freq_cmd', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  if pmt.is_pair(msg):
                      vec = pmt.cdr(msg)
                      data = bytes(pmt.u8vector_elements(vec))
                      freq = float(data.decode('utf-8'))
                      cmd = pmt.cons(pmt.intern("freq"), pmt.from_double(freq))
                      self.message_port_pub(pmt.intern('out'), cmd)
                      print("UDP Received freq =", freq)
              except Exception as e:
                  print("RX block error:", e)
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    fbw: '0.4'
    interp: '125'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 500e3
    center_freq0: '0'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [epy_block_0, out, qtgui_freq_sink_x_0, freq]
- [epy_block_0, out, uhd_usrp_sink_0, command]
- [network_socket_pdu_1, pdus, epy_block_0, in]
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
